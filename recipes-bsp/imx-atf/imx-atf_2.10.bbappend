FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-WPI-OP-Gyro-Fast-Boot-ATF-Modification.patch"
